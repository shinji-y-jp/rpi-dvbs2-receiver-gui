options:
  parameters:
    category: Custom
    description: Full DVB-S2 receiver. Processes IQ samples from stdin and outputs MPEG TS packets to stdout.
    generate_options: qt_gui
    id: dvbs2_rx
    output_language: python
    title: DVB-S2 Rx
  states: {}

blocks:
- name: code_rate
  id: variable
  parameters:
    value: modcod.upper().replace("8PSK", "").replace("QPSK", "")
  states: {}
- name: constellation
  id: variable
  parameters:
    value: modcod.replace(code_rate, "")
  states: {}
- name: pilot_len
  id: variable
  parameters:
    value: int((360-1)/16)*36
  states: {}
- name: plframe_len
  id: variable
  parameters:
    value: '33282'
  states: {}
- name: plheader_len
  id: variable
  parameters:
    value: '90'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sym_rate * sps
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    label: AGC gain
    type: eng_float
    value: '1'
  states: {}
- name: agc_rate
  id: parameter
  parameters:
    label: AGC update rate
    type: eng_float
    value: '1e-5'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    label: AGC's reference value
    type: eng_float
    value: '1'
  states: {}
- name: blocks_fd_sink
  id: blocks_file_descriptor_sink
  parameters:
    fd: out_fd
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: tmp.ts
    type: byte
  states: {}
- name: debug
  id: parameter
  parameters:
    label: debugging level
    short_id: d
    type: intx
    value: '0'
  states: {}
- name: dvbs2rx_rx_hier_0
  id: dvbs2rx_rx_hier
  parameters:
    agc_gain: agc_gain
    agc_rate: agc_rate
    agc_ref: agc_ref
    debug: debug
    frame_size: frame_size
    gold_code: gold_code
    modcod: modcod
    pl_freq_est_period: pl_freq_est_period
    rolloff: rolloff
    rrc_delay: rrc_delay
    rrc_nfilts: rrc_nfilts
    sps: sps
    sym_rate: sym_rate
    sym_sync_damping: sym_sync_damping
    sym_sync_loop_bw: sym_sync_loop_bw
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: FECFRAME size
    short_id: f
    type: str
    value: normal
  states: {}
- name: freq
  id: parameter
  parameters:
    label: center frequency
    short_id: g
    type: eng_float
    value: '438022000'
  states: {}
- name: gold_code
  id: parameter
  parameters:
    label: Gold code
    type: intx
    value: '0'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: in_fd
  id: parameter
  parameters:
    label: input file descriptor
    short_id: I
    type: intx
    value: '0'
  states: {}
- name: modcod
  id: parameter
  parameters:
    label: MODCOD
    short_id: m
    type: str
    value: QPSK1/4
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: byte
  states: {}
- name: out_fd
  id: parameter
  parameters:
    label: output file descriptor
    short_id: O
    type: intx
    value: '1'
  states: {}
- name: pl_freq_est_period
  id: parameter
  parameters:
    label: PL synchronizer's frequency estimation period in frames
    type: intx
    value: '20'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: rolloff factor
    short_id: r
    type: eng_float
    value: '0.2'
  states: {}
- name: rrc_delay
  id: parameter
  parameters:
    label: RRC filter delay in symbol periods
    type: intx
    value: '25'
  states: {}
- name: rrc_nfilts
  id: parameter
  parameters:
    label: number of branches on the polyphase RRC filter
    type: intx
    value: '128'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"RTL-SDR"'
    bb_gain0: '20'
    freq0: freq
    gain0: '15'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: sps
  id: parameter
  parameters:
    label: oversampling ratio in samples per symbol
    short_id: o
    type: eng_float
    value: '4'
  states: {}
- name: sym_rate
  id: parameter
  parameters:
    label: symbol rate in bauds
    short_id: s
    type: intx
    value: '333000'
  states: {}
- name: sym_sync_damping
  id: parameter
  parameters:
    label: symbol synchronizer's damping factor
    type: eng_float
    value: '1.0'
  states: {}
- name: sym_sync_loop_bw
  id: parameter
  parameters:
    label: symbol synchronizer's loop bandwidth
    type: eng_float
    value: '0.0045'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0
    label0: Input
    label1: Frequency Correction
    label2: Symbol Sync
    label3: Frame Recovery
    label4: Phase Recovery
    num_tabs: '5'
  states: {}

connections:
- [dvbs2rx_rx_hier_0, '0', blocks_fd_sink, '0']
- [dvbs2rx_rx_hier_0, '0', blocks_file_sink_0, '0']
- [dvbs2rx_rx_hier_0, '0', network_udp_sink_0, '0']
- [dvbs2rx_rx_hier_0, '2', qtgui_const_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', dvbs2rx_rx_hier_0, '0']
- [rtlsdr_source_0, '0', dvbs2rx_rx_hier_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
